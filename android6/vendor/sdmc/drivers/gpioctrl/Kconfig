## android6/vendor/sdmc/drivers/gpioctrl/Kconfig
```kconfig
config SDMC_GPIOCTRL
	tristate "sdmc gpio control driver"
	default m
	---help---
	  This is the sdmc gpio control driver
```
